# IAR project Project.ewp, settings and files
configuration STM32L476G-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx; USE_STM32L476G_DISCO_REVB; BSP_AUDIO_USE_RTOS; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\Core\inc; ..\Config; ..\Modules\audioplayer; ..\Modules\audiorecorder; ..\Modules\batterymeasure; ..\Modules\compass; ..\Modules\iddmeasure; ..\Modules\main_app; ..\Modules\soundmeter; ..\Modules\guitartuner; ..\..\..\..\Utilities\CPU; ..\Drivers\CMSIS\; ..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\Drivers\BSP\STM32L476G-Discovery; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\mbed; ..\compat; ..\third
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: STM32CubeDemo_STM32L476G-Discovery-MB1184-C01.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User/Core
    ../Core/Src/: lcd.cpp main.c stm32l4xx_it.c
  group Application/User/Misc
    ../Drivers/ILI9341_Display_Driver/third/: GraphicsDisplay.cpp SPI_TFT_ILI9341.cpp TextDisplay.cpp
    ../compat/: mbed_io.cpp mbed_stream.cpp
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../Drivers/BSP/Components/lsm303c/: lsm303c.c
    ../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32L476G-Discovery
    ../Drivers/BSP/STM32L476G-Discovery/: stm32l476g_discovery.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Drivers
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_fmc.c
